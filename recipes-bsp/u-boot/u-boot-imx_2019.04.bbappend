PATCHTOOL = "git"

FILESEXTRAPATHS_prepend := "${THISDIR}:"

SRC_URI += "file://0001-Set-custom-device-tree-as-fdt_file.patch "